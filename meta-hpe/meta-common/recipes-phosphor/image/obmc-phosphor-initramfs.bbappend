PACKAGE_INSTALL += "u-boot-fw-utils-gxp"
