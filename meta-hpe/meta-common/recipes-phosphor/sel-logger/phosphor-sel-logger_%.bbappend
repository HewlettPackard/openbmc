EXTRA_OECMAKE_append += " \
    -DREDFISH_LOG_MONITOR_PULSE_EVENTS=ON \
    "
