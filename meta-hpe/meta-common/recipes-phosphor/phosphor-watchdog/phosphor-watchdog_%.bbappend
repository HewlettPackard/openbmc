# Disable WATCHDOG in default
ENABLE_WATCHDOG_FMT = ""
