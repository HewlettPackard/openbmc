EXTRA_OECONF += " --disable-link-local-autoconfiguration"

