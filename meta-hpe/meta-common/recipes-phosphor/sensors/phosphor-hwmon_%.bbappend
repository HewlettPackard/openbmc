FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-DEV-Support-PWM-type-Fan-Declare-PWM_TARGET_xxx-in-c.patch \
            file://0001-DEV-Remove-retry-error-code-to-avoid-long-response-f.patch \
            "
