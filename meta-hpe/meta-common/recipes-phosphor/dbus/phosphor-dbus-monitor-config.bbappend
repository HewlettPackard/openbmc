PHOSPHOR_DBUS_MONITOR_CONFIGS_append = " snmp-native"
