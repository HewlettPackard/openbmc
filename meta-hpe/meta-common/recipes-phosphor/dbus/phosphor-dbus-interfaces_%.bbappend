FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-DEV-Add-Percentage-type-for-PWM-Fan.patch \
            file://0002-Add-CPU-and-DIMM-dbus-interface-definition.patch \
            "
