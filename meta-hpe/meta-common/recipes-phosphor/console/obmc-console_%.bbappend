FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-GXP-obmc-console-uart-udev-rules.patch"

