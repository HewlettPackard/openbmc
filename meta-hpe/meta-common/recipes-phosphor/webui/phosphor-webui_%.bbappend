FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-DEV-Display-symbol-for-percentage.patch \
            file://0001-Tweak-sensor-list-pages.patch \
            file://0001-Marked-unavailable-sensors-as-yellow-color-warning.patch \
            file://0001-Show-a-different-error-message-when-the-password-is-.patch \
            "
